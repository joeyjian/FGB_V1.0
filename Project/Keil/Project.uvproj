# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
    ../../Libraries/Include/: include.h
  group User
    ../../Libraries/Source/: rf_operate.c rf_spi.c debug.c
  group Fogic
    ../../User/: Fogic_COM.c Fogic_COM.h Fogic_RxD.c Fogic_RxD.h Fogic_TxD.c Fogic_TxD.h
